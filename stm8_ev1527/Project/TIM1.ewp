# IAR project TIM1.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S003F3 STM8S003F3
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: ..\FWlib\inc; ..\FWlib\src; ..\USER
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: TIM1.hex
  ILINK.IlinkOutputFile: TIM1.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group FWlib
    ../FWlib/src/: stm8s_clk.c stm8s_exti.c stm8s_flash.c stm8s_gpio.c stm8s_tim1.c
  group USER
    ../USER/: e2prom.c functions.c head.c main.c stm8s_it.c sysclock.c
